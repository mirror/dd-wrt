// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-16-a1", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-16";
};

&mdio_bus0 {
	PHY_C22(16)
	PHY_C22(17)
	PHY_C22(18)
	PHY_C22(19)
	PHY_C22(20)
	PHY_C22(21)
	PHY_C22(22)
	PHY_C22(23)
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT(16, 09, qsgmii)
		SWITCH_PORT(17, 10, qsgmii)
		SWITCH_PORT(18, 11, qsgmii)
		SWITCH_PORT(19, 12, qsgmii)
		SWITCH_PORT(20, 13, qsgmii)
		SWITCH_PORT(21, 14, qsgmii)
		SWITCH_PORT(22, 15, qsgmii)
		SWITCH_PORT(23, 16, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};
