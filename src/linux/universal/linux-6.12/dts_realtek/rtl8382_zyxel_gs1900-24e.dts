// SPDX-License-Identifier: GPL-2.0-or-later

#include "rtl8380_zyxel_gs1900.dtsi"
#include "rtl8380_zyxel_gs1900_gpio.dtsi"

/ {
	compatible = "zyxel,gs1900-24e-a1", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-24E";
};

&mdio_bus0 {
	PHY_C22(0)
	PHY_C22(1)
	PHY_C22(2)
	PHY_C22(3)
	PHY_C22(4)
	PHY_C22(5)
	PHY_C22(6)
	PHY_C22(7)

	PHY_C22(16)
	PHY_C22(17)
	PHY_C22(18)
	PHY_C22(19)
	PHY_C22(20)
	PHY_C22(21)
	PHY_C22(22)
	PHY_C22(23)
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT(1, 01, qsgmii)
		SWITCH_PORT(0, 02, qsgmii)
		SWITCH_PORT(3, 03, qsgmii)
		SWITCH_PORT(2, 04, qsgmii)
		SWITCH_PORT(5, 05, qsgmii)
		SWITCH_PORT(4, 06, qsgmii)
		SWITCH_PORT(7, 07, qsgmii)
		SWITCH_PORT(6, 08, qsgmii)

		SWITCH_PORT(9, 09, internal)
		SWITCH_PORT(8, 10, internal)
		SWITCH_PORT(11, 11, internal)
		SWITCH_PORT(10, 12, internal)
		SWITCH_PORT(13, 13, internal)
		SWITCH_PORT(12, 14, internal)
		SWITCH_PORT(15, 15, internal)
		SWITCH_PORT(14, 16, internal)

		SWITCH_PORT(17, 17, qsgmii)
		SWITCH_PORT(16, 18, qsgmii)
		SWITCH_PORT(19, 19, qsgmii)
		SWITCH_PORT(18, 20, qsgmii)
		SWITCH_PORT(21, 21, qsgmii)
		SWITCH_PORT(20, 22, qsgmii)
		SWITCH_PORT(23, 23, qsgmii)
		SWITCH_PORT(22, 24, qsgmii)
	};
};

&gpio1 {
	/delete-node/ poe_enable;
};
